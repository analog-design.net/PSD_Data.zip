# EAGLE board route01 (EAGLE 4.15), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$800  (via drill 0.8 pad 1.78) (continued)
  other vias: 16.51,86.36
N$801  (via drill 0.8 pad 1.78)
  other vias: 16.51,88.9
N$802  (via drill 0.8 pad 1.78)
  other vias: 16.51,91.44
N$803  (via drill 0.8 pad 1.78)
  other vias: 16.51,93.98
N$806  (via drill 0.8 pad 1.78)
  other vias: 19.05,93.98
N$807  (via drill 0.8 pad 1.78)
  other vias: 19.05,91.44
N$808  (via drill 0.8 pad 1.78)
  other vias: 21.59,91.44
N$809  (via drill 0.8 pad 1.78)
  other vias: 24.13,91.44
N$810  (via drill 0.8 pad 1.78)
  other vias: 26.67,91.44
N$811  (via drill 0.8 pad 1.78)
  other vias: 29.21,91.44
N$812  (via drill 0.8 pad 1.78)
  other vias: 31.75,91.44
N$813  (via drill 0.8 pad 1.78)
  other vias: 34.29,91.44
N$814  (via drill 0.8 pad 1.78)
  other vias: 26.67,86.36
N$815  (via drill 0.8 pad 1.78)
  other vias: 29.21,86.36
N$816  (via drill 0.8 pad 1.78)
  other vias: 31.75,86.36
N$817  (via drill 0.8 pad 1.78)
  other vias: 34.29,86.36
N$818  (via drill 0.8 pad 1.78)
  other vias: 34.29,93.98
N$819  (via drill 0.8 pad 1.78)
  other vias: 31.75,93.98
N$820  (via drill 0.8 pad 1.78)
  other vias: 29.21,93.98
N$821  (via drill 0.8 pad 1.78)
  other vias: 26.67,93.98
N$822  (via drill 0.8 pad 1.78)
  other vias: 24.13,93.98
N$823  (via drill 0.8 pad 1.78)
  other vias: 21.59,93.98
N$824  (via drill 0.8 pad 1.78)
  other vias: 21.59,88.9
N$825  (via drill 0.8 pad 1.78)
  other vias: 21.59,86.36
N$826  (via drill 0.8 pad 1.78)
  other vias: 21.59,83.82
N$827  (via drill 0.8 pad 1.78)
  other vias: 21.59,81.28
N$828  (via drill 0.8 pad 1.78)
  other vias: 34.29,83.82
N$829  (via drill 0.8 pad 1.78)
  other vias: 31.75,83.82
N$830  (via drill 0.8 pad 1.78)
  other vias: 29.21,83.82
N$831  (via drill 0.8 pad 1.78)
  other vias: 26.67,83.82
N$832  (via drill 0.8 pad 1.78)
  other vias: 24.13,83.82
N$833  (via drill 0.8 pad 1.78)
  other vias: 24.13,86.36
N$834  (via drill 0.8 pad 1.78)
  other vias: 24.13,88.9
N$835  (via drill 0.8 pad 1.78)
  other vias: 26.67,88.9
N$836  (via drill 0.8 pad 1.78)
  other vias: 29.21,88.9
N$837  (via drill 0.8 pad 1.78)
  other vias: 31.75,88.9
N$838  (via drill 0.8 pad 1.78)
  other vias: 34.29,88.9
N$839  (via drill 0.8 pad 1.78)
  other vias: 13.97,93.98
N$840  (via drill 0.8 pad 1.78)
  other vias: 11.43,93.98
N$841  (via drill 0.8 pad 1.78)
  other vias: 11.43,91.44
N$842  (via drill 0.8 pad 1.78)
  other vias: 19.05,88.9
N$843  (via drill 0.8 pad 1.78)
  other vias: 19.05,86.36
N$844  (via drill 0.8 pad 1.78)
  other vias: 19.05,83.82
N$845  (via drill 0.8 pad 1.78)
  other vias: 19.05,81.28
N$846  (via drill 0.8 pad 1.78)
  other vias: 13.97,91.44
N$847  (via drill 0.8 pad 1.78)
  other vias: 13.97,88.9
N$848  (via drill 0.8 pad 1.78)
  other vias: 13.97,86.36
N$849  (via drill 0.8 pad 1.78)
  other vias: 13.97,83.82
N$850  (via drill 0.8 pad 1.78)
  other vias: 11.43,83.82
N$851  (via drill 0.8 pad 1.78)
  other vias: 11.43,86.36
N$852  (via drill 0.8 pad 1.78)
  other vias: 11.43,88.9
N$853  (via drill 0.8 pad 1.78)
  other vias: 3.81,60.96
N$854  (via drill 0.8 pad 1.78)
  other vias: 3.81,63.5
N$855  (via drill 0.8 pad 1.78)
  other vias: 3.81,66.04
N$856  (via drill 0.8 pad 1.78)
  other vias: 3.81,68.58
N$857  (via drill 0.8 pad 1.78)
  other vias: 3.81,71.12
N$858  (via drill 0.8 pad 1.78)
  other vias: 6.35,68.58
N$859  (via drill 0.8 pad 1.78)
  other vias: 6.35,66.04
N$860  (via drill 0.8 pad 1.78)
  other vias: 6.35,63.5
N$861  (via drill 0.8 pad 1.78)
  other vias: 16.51,68.58
N$862  (via drill 0.8 pad 1.78)
  other vias: 16.51,66.04
N$863  (via drill 0.8 pad 1.78)
  other vias: 16.51,63.5
N$864  (via drill 0.8 pad 1.78)
  other vias: 21.59,63.5
N$865  (via drill 0.8 pad 1.78)
  other vias: 19.05,63.5
N$866  (via drill 0.8 pad 1.78)
  other vias: 13.97,63.5
N$867  (via drill 0.8 pad 1.78)
  other vias: 11.43,63.5
N$868  (via drill 0.8 pad 1.78)
  other vias: 8.89,63.5
N$869  (via drill 0.8 pad 1.78)
  other vias: 11.43,60.96
N$870  (via drill 0.8 pad 1.78)
  other vias: 11.43,58.42
N$871  (via drill 0.8 pad 1.78)
  other vias: 16.51,60.96
N$872  (via drill 0.8 pad 1.78)
  other vias: 16.51,58.42
N$873  (via drill 0.8 pad 1.78)
  other vias: 19.05,58.42
N$874  (via drill 0.8 pad 1.78)
  other vias: 19.05,60.96
N$875  (via drill 0.8 pad 1.78)
  other vias: 19.05,66.04
N$876  (via drill 0.8 pad 1.78)
  other vias: 19.05,68.58
N$877  (via drill 0.8 pad 1.78)
  other vias: 11.43,68.58
N$878  (via drill 0.8 pad 1.78)
  other vias: 11.43,66.04
N$879  (via drill 0.8 pad 1.78)
  other vias: 13.97,68.58
N$880  (via drill 0.8 pad 1.78)
  other vias: 13.97,66.04
N$881  (via drill 0.8 pad 1.78)
  other vias: 13.97,60.96
N$882  (via drill 0.8 pad 1.78)
  other vias: 13.97,58.42
N$883  (via drill 0.8 pad 1.78)
  other vias: 8.89,68.58
N$884  (via drill 0.8 pad 1.78)
  other vias: 8.89,66.04
N$885  (via drill 0.8 pad 1.78)
  other vias: 8.89,60.96
N$886  (via drill 0.8 pad 1.78)
  other vias: 8.89,58.42
N$887  (via drill 0.8 pad 1.78)
  other vias: 6.35,60.96
N$888  (via drill 0.8 pad 1.78)
  other vias: 6.35,58.42
N$889  (via drill 0.8 pad 1.78)
  other vias: 21.59,66.04
N$890  (via drill 0.8 pad 1.78)
  other vias: 21.59,60.96
N$891  (via drill 0.8 pad 1.78)
  other vias: 21.59,58.42
N$892  (via drill 0.8 pad 1.78)
  other vias: 3.81,78.74
N$893  (via drill 0.8 pad 1.78)
  other vias: 3.81,81.28
N$894  (via drill 0.8 pad 1.78)
  other vias: 3.81,83.82
N$895  (via drill 0.8 pad 1.78)
  other vias: 3.81,86.36
N$896  (via drill 0.8 pad 1.78)
  other vias: 3.81,88.9
N$897  (via drill 0.8 pad 1.78)
  other vias: 3.81,91.44
N$898
  Bottom 0.813: 6.35,55.88 6.35,71.12
N$899
  Bottom 0.813: 11.43,55.88 11.43,71.12
N$900
  Bottom 0.813: 13.97,55.88 13.97,71.12
N$901
  Bottom 0.813: 16.51,55.88 16.51,71.12
OFF  (3 unrouted)
ON  (3 unrouted)
OSC  (2 unrouted)
RESET  (4 unrouted)
S$2
  Bottom 0.813: 151.13,55.88 151.13,71.12
S$3
  Bottom 0.813: 107.95,55.88 107.95,71.12
S$4
  Bottom 0.813: 105.41,55.88 105.41,71.12
S$5
  Bottom 0.813: 110.49,55.88 110.49,71.12
S$6
  Bottom 0.813: 113.03,55.88 113.03,71.12
S$7
  Bottom 0.813: 115.57,55.88 115.57,71.12
S$8
  Bottom 0.813: 118.11,55.88 118.11,71.12
S$9
  Bottom 0.813: 120.65,55.88 120.65,71.12
S$10
  Bottom 0.813: 123.19,55.88 123.19,71.12
S$11
  Bottom 0.813: 128.27,55.88 128.27,71.12
S$12
  Bottom 0.813: 125.73,55.88 125.73,71.12
S$13
  Bottom 0.813: 133.35,55.88 133.35,71.12
S$14
  Bottom 0.813: 135.89,55.88 135.89,71.12
S$15
  Bottom 0.813: 130.81,55.88 130.81,71.12
S$16
  Bottom 0.813: 140.97,55.88 140.97,71.12
S$17
  Bottom 0.813: 146.05,55.88 146.05,71.12
S$18
  Bottom 0.813: 143.51,55.88 143.51,71.12
S$19
  Bottom 0.813: 138.43,55.88 138.43,71.12
S$20
  Bottom 0.813: 156.21,55.88 156.21,71.12
S$21
  Bottom 0.813: 153.67,55.88 153.67,71.12
S$22
  Bottom 0.813: 148.59,55.88 148.59,71.12
S$23
  Bottom 0.813: 102.87,55.88 102.87,71.12
S$24
  Bottom 0.813: 90.17,55.88 90.17,71.12
S$25
  Bottom 0.813: 92.71,55.88 92.71,71.12
S$26
  Bottom 0.813: 95.25,55.88 95.25,71.12
S$27
  Bottom 0.813: 97.79,55.88 97.79,71.12
S$28
  Bottom 0.813: 100.33,55.88 100.33,71.12
S$29
  Bottom 0.813: 87.63,55.88 87.63,71.12
S$30
  Bottom 0.813: 85.09,55.88 85.09,71.12
S$31
  Bottom 0.813: 82.55,55.88 82.55,71.12
S$32
  Bottom 0.813: 80.01,55.88 80.01,71.12
S$33
  Bottom 0.813: 77.47,55.88 77.47,71.12
S$34
  Bottom 0.813: 72.39,55.88 72.39,71.12
S$35
  Bottom 0.813: 64.77,55.88 64.77,71.12
S$36
  Bottom 0.813: 67.31,55.88 67.31,71.12
S$37
  Bottom 0.813: 69.85,55.88 69.85,71.12
S$38
  Bottom 0.813: 74.93,55.88 74.93,71.12
S$39
  Bottom 0.813: 3.81,55.88 3.81,71.12
S$40
  Bottom 0.813: 8.89,55.88 8.89,71.12
S$41
  Bottom 0.813: 19.05,55.88 19.05,71.12
S$42
  Bottom 0.813: 21.59,55.88 21.59,71.12
S$43
  Bottom 0.813: 24.13,55.88 24.13,71.12
S$44
  Bottom 0.813: 26.67,55.88 26.67,71.12
S$45
  Bottom 0.813: 29.21,55.88 29.21,71.12
S$46
  Bottom 0.813: 31.75,55.88 31.75,71.12
S$47
  Bottom 0.813: 36.83,55.88 36.83,71.12
S$48
  Bottom 0.813: 34.29,55.88 34.29,71.12
S$49
  Bottom 0.813: 54.61,55.88 54.61,71.12
S$50
  Bottom 0.813: 52.07,55.88 52.07,71.12
S$51
  Bottom 0.813: 62.23,55.88 62.23,71.12
S$52
  Bottom 0.813: 59.69,55.88 59.69,71.12
S$53
  Bottom 0.813: 57.15,55.88 57.15,71.12
S$54
  Bottom 0.813: 49.53,55.88 49.53,71.12
S$55
  Bottom 0.813: 46.99,55.88 46.99,71.12
S$56
  Bottom 0.813: 44.45,55.88 44.45,71.12
S$57
  Bottom 0.813: 41.91,55.88 41.91,71.12
S$58
  Bottom 0.813: 6.35,78.74 6.35,93.98
S$59
  Bottom 0.813: 3.81,78.74 3.81,91.44
S$60
  Bottom 0.813: 31.75,78.74 31.75,93.98
S$61
  Bottom 0.813: 82.55,78.74 82.55,93.98
S$62
  Bottom 0.813: 85.09,78.74 85.09,93.98
S$63
  Bottom 0.813: 87.63,78.74 87.63,93.98
S$64
  Bottom 0.813: 90.17,78.74 90.17,93.98
S$65
  Bottom 0.813: 77.47,78.74 77.47,93.98
S$66
  Bottom 0.813: 72.39,78.74 72.39,93.98
S$67
  Bottom 0.813: 69.85,78.74 69.85,93.98
S$68
  Bottom 0.813: 67.31,78.74 67.31,93.98
S$69
  Bottom 0.813: 64.77,78.74 64.77,93.98
S$70
  Bottom 0.813: 62.23,78.74 62.23,93.98
S$71
  Bottom 0.813: 59.69,78.74 59.69,93.98
S$72
  Bottom 0.813: 57.15,78.74 57.15,93.98
S$73
  Bottom 0.813: 54.61,78.74 54.61,93.98
S$74
  Bottom 0.813: 52.07,78.74 52.07,93.98
S$75
  Bottom 0.813: 46.99,78.74 46.99,93.98
S$76
  Bottom 0.813: 44.45,78.74 44.45,93.98
S$77
  Bottom 0.813: 49.53,78.74 49.53,93.98
S$78
  Bottom 0.813: 39.37,78.74 39.37,93.98
S$79
  Bottom 0.813: 36.83,78.74 36.83,93.98
S$80
  Bottom 0.813: 41.91,78.74 41.91,93.98
S$81
  Bottom 0.813: 26.67,78.74 26.67,93.98
S$82
  Bottom 0.813: 24.13,78.74 24.13,93.98
S$83
  Bottom 0.813: 21.59,78.74 21.59,93.98
S$84  (via drill 0.8 pad 1.78)
  Bottom 0.813: v29.21,78.74 29.21,93.98
S$85
  Bottom 0.813: 34.29,78.74 34.29,93.98
S$86
  Bottom 0.813: 19.05,78.74 19.05,93.98
S$87
  Bottom 0.813: 16.51,78.74 16.51,93.98
S$88
  Bottom 0.813: 13.97,78.74 13.97,93.98
S$89
  Bottom 0.813: 11.43,78.74 11.43,93.98
S$90
  Bottom 0.813: 8.89,78.74 8.89,93.98
S$91
  Bottom 0.813: 80.01,78.74 80.01,93.98
S$92
  Bottom 0.813: 74.93,78.74 74.93,93.98
S$93
  Bottom 0.813: 95.25,78.74 95.25,93.98
S$94
  Bottom 0.813: 100.33,78.74 100.33,93.98
S$95
  Bottom 0.813: 97.79,78.74 97.79,93.98
S$96
  Bottom 0.813: 92.71,78.74 92.71,93.98
S$97
  Bottom 0.813: 105.41,78.74 105.41,93.98
S$98
  Bottom 0.813: 107.95,78.74 107.95,93.98
S$99
  Bottom 0.813: 102.87,78.74 102.87,93.98
S$100
  Bottom 0.813: 113.03,78.74 113.03,93.98
S$101
  Bottom 0.813: 115.57,78.74 115.57,93.98
S$102
  Bottom 0.813: 110.49,78.74 110.49,93.98
S$103
  Bottom 0.813: 118.11,78.74 118.11,93.98
S$104
  Bottom 0.813: 120.65,78.74 120.65,93.98
S$105
  Bottom 0.813: 125.73,78.74 125.73,93.98
S$106
  Bottom 0.813: 135.89,78.74 135.89,93.98
S$107
  Bottom 0.813: 133.35,78.74 133.35,93.98
S$108
  Bottom 0.813: 130.81,78.74 130.81,93.98
S$109
  Bottom 0.813: 128.27,78.74 128.27,93.98
S$110
  Bottom 0.813: 123.19,78.74 123.19,93.98
S$111
  Bottom 0.813: 151.13,78.74 151.13,93.98
S$112
  Bottom 0.813: 146.05,78.74 146.05,93.98
S$113
  Bottom 0.813: 143.51,78.74 143.51,93.98
S$114
  Bottom 0.813: 138.43,78.74 138.43,93.98
S$115
  Bottom 0.813: 156.21,78.74 156.21,91.44
S$116
  Bottom 0.813: 153.67,78.74 153.67,91.44
S$117
  Bottom 0.813: 148.59,78.74 148.59,93.98
SIRENE  (1 unrouted)
TEMPO  (1 unrouted)
V+  (28 unrouted)
VDD  (4 unrouted)
VSS  (4 unrouted)